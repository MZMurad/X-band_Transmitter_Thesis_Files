options:
  parameters:
    author: Barry Duggan, modified by Gary Schafer
    category: Custom
    generate_options: qt_gui
    id: qpsk_modem
    output_language: python
    title: QPSK Modulator / Demodulator (modem)
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: f0
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: 0.0628*2
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    comment: |-
      Symbol Map: [0,1,3,2] <- This is Gray coding
      Constellation Points: [-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6*5
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: replace_with_output_file_path
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '''packet_len'''
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: '''packet_len'''
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: 3*math.pi/200
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Gray coding
    map: '[0,1,3,2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    comment: |-
      Symbol Rate: samp_rate/sps
      Alpha: excess_bw
      Num Taps: 11*sps
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '50'
    oversample: '0'
    rf_freq: 1e9
    samp_rate: samp_rate
    serial: 1DA14FB9626A6D
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: '50'
    oversample: '0'
    rf_freq: f0
    samp_rate: samp_rate
    serial: 1DA14FB9626A6D
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '1'
    grid: 'True'
    gui_hint: 2,0,10,10
    label1: Synced Only
    label2: Synced & Phase-Locked
    name: Synced Constellation
    nconnections: '2'
    size: '1024'
    type: complex
    width2: '2'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 12,0,10,20
    label1: Transmitted & Propagated
    label2: Received & Filtered
    name: Transmitted & Received Spectrum
    nconnections: '2'
    type: complex
    ymax: '-10'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: decoded_signal
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_signal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: filtered_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: decoded_signal
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}

connections:
- [blocks_null_source_0, '0', limesdr_sink_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_4, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', filter_fft_rrc_filter_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [filter_fft_rrc_filter_0, '0', virtual_sink_0, '0']
- [limesdr_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_1, '0', digital_diff_decoder_bb_0, '0']
- [virtual_source_3, '0', blocks_repack_bits_bb_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
